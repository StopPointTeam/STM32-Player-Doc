# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H750xx
  c include: ..\CORE;..\USER;..\USMART;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\MPU;..\HARDWARE\RTC;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\OV5640;..\HARDWARE\DCMI;..\HARDWARE\TIMER;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\IWDG;..\HARDWARE\WWDG;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\OLED;..\HARDWARE\PWM_ADC;..\HARDWARE\DMA;..\HARDWARE\QSPI;..\HARDWARE\NORFLASH;..\HARDWARE\FDCAN;..\HARDWARE\STMFLASH;..\HARDWARE\GBK_LibDrive;..\HARDWARE\LCD200H
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=6314,6329
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h750xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_ll_fmc.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sram.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_spi.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/SPI/: spi.c
  group README
    ../: readme.txt
  group LCD200H
    ../HARDWARE/LCD200H/: Dis_Picture.c FONT.c lcd.c Picture.c Text.c
    ../HARDWARE/GBK_LibDrive/: GBK_LibDrive.c
